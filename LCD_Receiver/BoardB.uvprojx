# Keil uVision project BoardB.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BoardB
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;..\common\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Files
    ./src/: main.c UART.c queue.c switches.c
    ../common/src/: delay.c LCD_4bit.c
  group Include Files
    ./inc/: gpio_defs.h UART.h queue.h switches.h
    ../common/inc/: LCD_4bit.h delay.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
